# IAR project Project.ewp, settings and files
configuration IHM06A1_ExampleFor1Motor_STM32F401RE-Nucleo (ARM, debug)
  General.OGChipSelectEditMenu: STM32F401xE ST STM32F401xE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F401xE; USE_STM32F4XX_NUCLEO
  ICCARM.CCIncludePath2: ..\..\Inc; ..\..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include; ..\..\..\..\..\..\..\Drivers\STM32F4xx_HAL_Driver\Inc; ..\..\..\..\..\..\..\Drivers\BSP\STM32F4xx-Nucleo; ..\..\..\..\..\..\..\Drivers\BSP\MotorControl; ..\..\..\..\..\..\..\Drivers\BSP\Components\stspin220; ..\..\..\..\..\..\..\Drivers\BSP\Components\Common
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.bin
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32f401xe_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Doc
    ../../: readme.txt
  group Drivers/BSP/Components/stspin220
    ../../../../../../../Drivers/BSP/Components/stspin220/: stspin220.c
  group Drivers/BSP/MotorControl
    ../../../../../../../Drivers/BSP/MotorControl/: motorcontrol.c
  group Drivers/BSP/STM32F4xx-Nucleo
    ../../../../../../../Drivers/BSP/STM32F4xx-Nucleo/: stm32f4xx_nucleo.c stm32f4xx_nucleo_ihm06a1.c
  group Drivers/CMSIS
    ../../Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c
  group Example/EWARM
    ./: startup_stm32f401xe.s
  group Example/User
    ../../Src/: clock_f4.c main.c stm32f4xx_hal_msp.c stm32f4xx_it.c
