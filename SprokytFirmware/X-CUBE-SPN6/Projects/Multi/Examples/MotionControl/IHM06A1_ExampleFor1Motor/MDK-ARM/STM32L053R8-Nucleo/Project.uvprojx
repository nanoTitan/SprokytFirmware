# Keil uVision project Project.uvprojx, settings and files
target STM32L053R8-Nucleo (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32L053R8 STMicroelectronics
  pack: Keil.STM32L0xx_DFP.1.1.0
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0+")
  output: STM32L053R8-Nucleo +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=$l@L.bin !L
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32L053xx,USE_STM32L0XX_NUCLEO,USE_HAL_DRIVER,
  c misc: --C99
  c include: ..\..\Inc;..\..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32L0xx\Include;..\..\..\..\..\..\..\Drivers\STM32L0xx_HAL_Driver\Inc;..\..\..\..\..\..\..\Drivers\BSP\STM32L0xx_Nucleo;..\..\..\..\..\..\..\Drivers\BSP\Components\stspin220;..\..\..\..\..\..\..\Drivers\BSP\Components\Common;..\..\..\..\..\..\..\Drivers\BSP\MotorControl
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --diag_suppress=L6329
  group Doc
    ../../: readme.txt
  group Drivers/BSP/Components/stspin220
    ../../../../../../../Drivers/BSP/Components/stspin220/: stspin220.c
  group Drivers/BSP/MotorControl
    ../../../../../../../Drivers/BSP/MotorControl/: motorcontrol.c
  group Drivers/BSP/STM32L053R8_NUCLEO
    ../../../../../../../Drivers/BSP/STM32L0xx_Nucleo/: stm32l0xx_nucleo.c stm32l0xx_nucleo_ihm06a1.c
  group Drivers/CMSIS
    ../../Src/: system_stm32l0xx.c
  group Drivers/STM32L0xx_HAL_Driver
    ../../../../../../../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal.c stm32l0xx_hal_cortex.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_gpio.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_spi.c stm32l0xx_hal_tim.c stm32l0xx_hal_tim_ex.c stm32l0xx_hal_adc.c stm32l0xx_hal_adc_ex.c stm32l0xx_hal_dma.c
  group Example/MDK-ARM
    ./: startup_stm32l053xx.s
  group Example/User
    ../../Src/: main.c stm32l0xx_hal_msp.c stm32l0xx_it.c clock_l0.c
software components: CMSIS:CORE 3.40.0
